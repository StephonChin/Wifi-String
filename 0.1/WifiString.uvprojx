# Keil uVision project WifiString.uvprojx, settings and files
target WifiString (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Mini58FDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: WifiString +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group Src
    ./Src/: Data_Process.c Display_Ctrl.c Flash_Prgrm.c Key.c Led_Class.c MCU_Config.c Normal_Display.c Show_1.c Show_2.c Show_3.c Timer_Ctrl.c USART.c WifiString.c
  group Inc
    ./Inc/: Data_Process.h Display_Ctrl.h Flash_Prgrm.h Key.h Led_Class.h MCU_Config.h Timer_Ctrl.h Type_Def.h Type_Private.h USART.h WifiString.h
software components: CMSIS:CORE 5.0.2, Device:Driver:CLK 3.00.003, Device:Driver:FMC 3.00.003, Device:Driver:GPIO 3.00.003, Device:Driver:SYS 3.00.003, Device:Driver:Timer 3.00.003, Device:Driver:UART 3.00.003, Device:Driver:WDT 3.00.003, Device:Startup 3.00.003
